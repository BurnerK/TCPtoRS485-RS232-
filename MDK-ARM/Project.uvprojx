# Keil uVision project Project.uvprojx, settings and files
target ZFWL_V1.0 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\ucCos_App;..\USER\uC-CPU;..\USER\uC-LIB;..\USER\uCOS-II;..\USER\uCOS-VIEW;..\Libraries\STM32_ETH_Driver\inc;..\USER\lwip-1.3.2;..\USER\lwip-1.3.2\src;..\USER\lwip-1.3.2\src\api;..\USER\lwip-1.3.2\src\netif;..\USER\lwip-1.3.2\src\core;..\USER\lwip-1.3.2\src\arch;..\USER\lwip-1.3.2\src\include;..\USER\lwip-1.3.2\src\core\ipv4;..\USER\lwip-1.3.2\src\include\lwip;..\USER\lwip-1.3.2\src\include\netif;..\USER\lwip-1.3.2\src\include\arch;..\USER\lwip-1.3.2\src\include\ipv4\lwip;..\USER\GLCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../USER/: main.c stm32f10x_it.c webpage.h stm32f10x_conf.h SCI.c uctsk_TCP_client.c uctsk_TCP_sever.c TCP_to_RS232_485.C stm32f107.c
    ../USER/lwip-1.3.2/src/: search.c
    ../USER/ucCos_App/: uctsk_Blink.c uctsk_OSView.c app_cfg.h includes.h
    ../USER/lwip-1.3.2/: lwipopts.h lwipconfig.h
  group GLCD
    ../USER/GLCD/: HzLib.c AsciiLib.c GLCD.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_ETH_Driver
    ../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group uC-OS-II/Port
    ../USER/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_dbg.c os_cpu_c.c os_cpu.h os_cpu_a.asm
  group uC-OS-II/Source
    ../USER/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Config
    ../USER/ucCos_App/: OS_AppHooks.c os_cfg.h
  group uC-OS-II/CPU
    ../USER/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm cpu.h
    ../USER/uC-CPU/: cpu_def.h
  group uC-OS-II/LIB/Source
    ../USER/uC-LIB/: lib_mem.c lib_str.c lib_def.h lib_mem.h lib_str.h
  group uC-OS-II/LIB/Port
    ../USER/uC-LIB/Ports/RealView/: lib_mem_a.asm
  group uC-OS-II/VIEW/Source
    ../USER/uCOS-VIEW/Source/: os_view.c os_view.h
  group uC-OS-II/VIEW/Port
    ../USER/uCOS-VIEW/Ports/ARM-Cortex-M3/Realview/: os_viewc.c os_viewc.h
  group LWIP_1.3.2_Core
    ../USER/lwip-1.3.2/src/core/: dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c
    ../USER/lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../USER/lwip-1.3.2/src/netif/: etharp.c
  group LWIP_1.3.2_Arch
    ../USER/lwip-1.3.2/src/: lwip.c lwip.h
    ../USER/lwip-1.3.2/src/arch/: sys_arch.c
    ../USER/lwip-1.3.2/src/netif/: ethernetif.c
    ../USER/lwip-1.3.2/src/include/lwip/: err.h opt.h debug.h
  group LWIP_1.3.2_Api
    ../USER/lwip-1.3.2/src/api/: err.c tcpip.c netdb.c netbuf.c api_lib.c sockets.c api_msg.c netifapi.c
  group Doc
    ../: readme.txt
